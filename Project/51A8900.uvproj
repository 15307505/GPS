# Keil uVision project 51A8900.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 51A8900 +hex
  c flags: Optimize=9
  c include: ..\Hardware\A8900;..\Hardware\Delay;..\Hardware\EEPROM;..\Hardware\GPIO;..\Hardware\GPS;..\Hardware\MoveData;..\Hardware\Timer;..\Hardware\UART;..\User;..\Project
  asm include: ..\Hardware\A8900;..\Hardware\Delay;..\Hardware\EEPROM;..\Hardware\GPIO;..\Hardware\GPS;..\Hardware\MoveData;..\Hardware\Timer;..\Hardware\UART;..\User
  group Source Group 1
    ../User/: main.c
    ../Hardware/A8900/: A8900.c
    ../Hardware/Delay/: delay.c
    ../Hardware/EEPROM/: eeprom.c
    ../Hardware/GPIO/: GPIO.c
    ../Hardware/MoveData/: MoveData.c
    ../Hardware/Timer/: Time.c
    ../Hardware/UART/: uart.c
    ../Hardware/GPS/: GPS.c
